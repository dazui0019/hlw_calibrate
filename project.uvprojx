# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: RT_USING_ARMLIBC, RT_USING_LIBC, GD32F470, __CLK_TCK=RT_TICK_PER_SECOND, USE_STDPERIPH_DRIVER, __RTTHREAD__, __STDC_LIMIT_MACROS
  c include: .;libraries\cd4051;libraries\meter;middleware\rt-thread\components\drivers\include;middleware\libraries\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;middleware\rt-thread\components\libc\posix\ipc;middleware\rt-thread\components\libc\compilers\common\extension;middleware\rt-thread\components\drivers\phy;applications;middleware\rt-thread\components\drivers\spi\sfud\inc;middleware\rt-thread\libcpu\arm\common;middleware\rt-thread\components\finsh;middleware\rt-thread\components\drivers\include;middleware\rt-thread\components\libc\posix\io\eventfd;libraries\SEGGER_RTT_V810k;middleware\rt-thread\components\drivers\include;middleware\rt-thread\components\libc\posix\io\epoll;middleware\rt-thread\components\drivers\include;middleware\rt-thread\components\utilities\ulog;middleware\rt-thread\components\drivers\include;middleware\libraries\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;middleware\rt-thread\components\dfs\dfs_v1\filesystems\devfs;middleware\rt-thread\components\drivers\smp_call;libraries\sfud_port;libraries\hlw8032;middleware\rt-thread\components\drivers\spi;middleware\rt-thread\components\drivers\include;middleware\rt-thread\components\libc\posix\io\poll;middleware\rt-thread\components\dfs\dfs_v1\include;middleware\rt-thread\include;middleware\libraries\gd32_drivers;middleware\libraries\GD32F4xx_Firmware_Library\CMSIS;middleware\rt-thread\components\libc\compilers\common\include;middleware\rt-thread\components\drivers\include;middleware\rt-thread\components\drivers\include;middleware\rt-thread\components\drivers\include;middleware\rt-thread\libcpu\arm\cortex-m4;middleware\rt-thread\components\libc\compilers\common\extension\fcntl\octal;board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App/Libraries
    libraries/cd4051/: drv_cd4051.c
    libraries/meter/: drv_meter.c
    libraries/SEGGER_RTT_V810k/: drv_rtt.c SEGGER_RTT_printf.c SEGGER_RTT.c
    libraries/hlw8032/: drv_hlw8032.c
  group App/Libraries/gd25q32
    libraries/sfud_port/: sfud_port.c
  group Applications
    applications/: dev_lock.c evse_main_thread.c dev_relay.c evse_main.c
  group Compiler
    middleware/rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    middleware/rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    middleware/rt-thread/components/drivers/core/: device.c
    middleware/rt-thread/components/drivers/hwtimer/: hwtimer.c
    middleware/rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    middleware/rt-thread/components/drivers/misc/: adc.c
    middleware/rt-thread/components/drivers/pin/: dev_pin.c
    middleware/rt-thread/components/drivers/rtc/: dev_alarm.c dev_rtc.c
    middleware/rt-thread/components/drivers/serial/: dev_serial.c
    middleware/rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    middleware/rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/: board.c
    middleware/libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    middleware/libraries/gd32_drivers/: drv_gpio.c drv_rtc.c drv_spi.c drv_timer.c drv_usart.c
  group Filesystem
    middleware/rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    middleware/rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    middleware/rt-thread/components/finsh/: msh.c shell.c msh_file.c msh_parse.c cmd.c
  group Kernel
    middleware/rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    middleware/rt-thread/src/klibc/: rt_vsscanf.c kstring.c kstdio.c rt_vsnprintf_std.c kerrno.c
  group libcpu
    middleware/rt-thread/libcpu/arm/common/: div0.c showmem.c
    middleware/rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    middleware/libraries/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_misc.c gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_pmu.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_adc.c gd32f4xx_spi.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_rcu.c gd32f4xx_rtc.c
    middleware/libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Utilities
    middleware/rt-thread/components/utilities/ulog/: ulog.c
    middleware/rt-thread/components/utilities/ulog/backend/: console_be.c
software components: CMSIS:CORE 6.1.0
